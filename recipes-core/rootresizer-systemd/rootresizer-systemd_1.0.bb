#
# Recipe for system updater program
#
SRCREV = "${AUTOREV}"

require rootresizer-systemd.inc
