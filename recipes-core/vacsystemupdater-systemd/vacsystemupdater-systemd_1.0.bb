#
# Recipe for system updater program
#
SRCREV = "${AUTOREV}"

require vacsystemupdater-systemd.inc
