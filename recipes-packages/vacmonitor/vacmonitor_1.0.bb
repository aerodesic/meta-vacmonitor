#
# Recipe for vacmonitor
#
# Uncomment when branch release has been set
# APP_BRANCH="branch=${PV}"

require vacmonitor.inc
