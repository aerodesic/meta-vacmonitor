require vacmonitor-version.inc
